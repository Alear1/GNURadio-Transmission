options:
  parameters:
    author: groundstation
    generate_options: qt_gui
    id: gmsk_tx_feb21
    output_language: python
    title: GMSK Transmitter Feb 21
  states: {}

blocks:
- name: baud_multiplier
  id: variable
  parameters:
    value: '200'
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center Frequency
    orient: Qt.Horizontal
    start: '434000000'
    step: '100000'
    stop: '437500000'
    value: '435500000'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud_rate * baud_multiplier
  states: {}
- name: transmit_volume
  id: variable_qtgui_range
  parameters:
    label: Transmit Volume
    min_len: '100'
    orient: Qt.Vertical
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
    widget: slider
  states: {}
- name: transmitter_bb
  id: variable_qtgui_range
  parameters:
    label: Transmitter BB Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: transmitter_if
  id: variable_qtgui_range
  parameters:
    label: Transmitter IF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: transmitter_rf
  id: variable_qtgui_range
  parameters:
    label: Transmitter RF gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '40'
    value: '0'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/groundstation/Documents/GS-Radio/Digital/GMSK-20220221-1348.raw
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/groundstation/Documents/GS-Radio/Digital/gmsk-test.raw
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: transmit_volume
    type: complex
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: 0.35*3
    samples_per_symbol: baud_multiplier
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: transmitter_bb
    freq0: center_freq
    gain0: transmitter_rf
    if_gain0: transmitter_if
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_file_sink_0, '0']
- [analog_random_source_x_0, '0', digital_gmsk_mod_0, '0']
- [blocks_file_source_0, '0', digital_gmsk_mod_0, '0']
- [blocks_multiply_const_vxx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gmsk_mod_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
