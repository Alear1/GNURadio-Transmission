options:
  parameters:
    author: groundstation
    generate_options: qt_gui
    id: gmsk_rec_feb21
    output_language: python
    title: GMSK Receive
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    label: BB Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '435500000'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '200'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud_rate * samp_per_sym
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/groundstation/Documents/GS-Radio/Digital/Data_files/Byte-Test-B.raw
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '0'
    bb_gain0: bb_gain
    freq0: center_freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    interp: '1'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_quadrature_demod_cf_1, '0', rational_resampler_xxx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', analog_quadrature_demod_cf_1, '0']
- [osmosdr_source_0, '0', qtgui_const_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', digital_binary_slicer_fb_0, '0']

metadata:
  file_format: 1
