options:
  parameters:
    author: groundstation
    generate_options: qt_gui
    id: gmsk_rec_feb21
    output_language: python
    title: GMSK Rx Feb21
  states: {}

blocks:
- name: beta
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: k3 (IP3)
    orient: Qt.Horizontal
    start: '-.1'
    step: '0.001'
    stop: '0'
    value: '0'
  states: {}
- name: const_size
  id: variable
  parameters:
    value: '4'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Frequency Offset
    orient: Qt.Horizontal
    start: '-0.5'
    step: '0.001'
    stop: '0.5'
    value: '0'
  states: {}
- name: i_ofs
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: I offset
    orient: Qt.Horizontal
    start: '-1'
    step: '0.001'
    stop: '1'
    value: '0'
  states: {}
- name: magbal
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: IQ Magnitude Imbalance
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: phase_noise_mag
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1,1
    label: Phase Noise Mag (dB)
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '0'
    value: '-100'
  states: {}
- name: phasebal
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: IQ Phase Imbalance
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '45'
    value: '0'
  states: {}
- name: q_ofs
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Q offset
    orient: Qt.Horizontal
    start: '-1'
    step: '0.001'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: '10'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/groundstation/Documents/GS-Radio/Digital/Data_files/Byte-Test-B.raw
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/groundstation/Documents/GS-Radio/Digital/sendTest.raw
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_impairments_0
  id: channels_impairments
  parameters:
    beta: beta
    freq_offset: freq_offset
    gamma: '0'
    i_ofs: i_ofs
    magbal: magbal
    phase_noise_mag: phase_noise_mag
    phasebal: phasebal
    q_ofs: q_ofs
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.3'
    samples_per_symbol: '10'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    note: BITS ARE BEING READ AS BYTES
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: quad
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: quad
  states: {}

connections:
- [analog_quadrature_demod_cf_1, '0', qtgui_time_sink_x_0, '0']
- [analog_quadrature_demod_cf_1, '0', virtual_sink_0, '0']
- [analog_random_source_x_0, '0', digital_gmsk_mod_0, '0']
- [blocks_file_source_0, '0', digital_gmsk_mod_0, '0']
- [blocks_throttle_0, '0', channels_impairments_0, '0']
- [channels_impairments_0, '0', analog_quadrature_demod_cf_1, '0']
- [channels_impairments_0, '0', qtgui_const_sink_x_1, '0']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0, '0']
- [digital_gmsk_mod_0, '0', blocks_throttle_0, '0']
- [rational_resampler_xxx_0, '0', digital_binary_slicer_fb_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
