options:
  parameters:
    generate_options: qt_gui
    id: fmTransmitter_noaaApt
    output_language: python
    title: noaaAPTtransmitter
  states: {}

blocks:
- name: QD_rate_multiplier
  id: variable
  parameters:
    value: '1'
  states: {}
- name: RR_inter_rate
  id: variable
  parameters:
    value: '100'
  states: {}
- name: audio_level
  id: variable_qtgui_range
  parameters:
    label: audio level
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '22'
    value: '1'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '22050'
  states: {}
- name: lowPassFilt_cutOff_freq
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '10000'
  states: {}
- name: lowPassFilt_tranWidt_freq
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '2000'
  states: {}
- name: noise_level
  id: variable_qtgui_range
  parameters:
    label: noise level
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '10'
    value: '0'
  states: {}
- name: ratiResa_fracBand
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '0.001'
  states: {}
- name: sink_bandwidth
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '0'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: 5e3
    quad_rate: QD_rate_multiplier*audio_rate
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: QD_rate_multiplier*audio_rate
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: QD_rate_multiplier
    quad_rate: audio_rate*QD_rate_multiplier
  states: {state: disabled}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: audio_rate*QD_rate_multiplier
    tau: '75e-6'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: audio_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_level
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/hooman/Documents/gnuHOOMAN/gr projects/fmTransmitter_noaaApt_20211216/audio sample/CantinaBand60.wav
    repeat: 'True'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise_level
    seed: '0'
    taps: 1.0 + 1.0j
  states: {state: bypassed}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lowPassFilt_cutOff_freq
    decim: '1'
    gain: '1'
    samp_rate: QD_rate_multiplier*audio_rate
    type: fir_filter_ccf
    width: lowPassFilt_tranWidt_freq
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '1'
    bw0: sink_bandwidth
    freq0: 435.5e6
    gain0: '10'
    if_gain0: '1'
    sample_rate: audio_rate*QD_rate_multiplier*RR_inter_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: audio_rate*5
    fc: '0'
    fftsize: '1024'
    name: '"Audio Out"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: audio_rate*4
    fc: '0'
    fftsize: '1024'
    name: '"Audio In"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: audio_rate
    fc: '100000'
    fftsize: '1024'
    name: '"FM"'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: ratiResa_fracBand
    interp: RR_inter_rate
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: RR_inter_rate
    fbw: ratiResa_fracBand
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_nbfm_tx_0, '0', low_pass_filter_0, '0']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_wfm_tx_0, '0', low_pass_filter_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', analog_nbfm_tx_0, '0']
- [blocks_add_xx_0, '0', analog_wfm_tx_0, '0']
- [blocks_add_xx_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_add_xx_0, '0']
- [channels_channel_model_0, '0', osmosdr_sink_0, '0']
- [channels_channel_model_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', channels_channel_model_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_nbfm_rx_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
