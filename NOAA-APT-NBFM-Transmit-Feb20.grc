options:
  parameters:
    author: groundstation
    generate_options: qt_gui
    id: Feb18_FMTransmit
    output_language: python
    title: FM transmitter
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '37500'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center Frequency
    min_len: '100'
    orient: Qt.Horizontal
    start: '137500000'
    step: '100000'
    stop: '141000000'
    value: '140000000'
    widget: counter
  states: {}
- name: filter_cutoff
  id: variable_qtgui_range
  parameters:
    label: Filter Cutoff Freq
    min_len: '100'
    orient: Qt.Horizontal
    rangeType: int
    start: '1000'
    step: '500'
    stop: '80000'
    value: '10000'
  states: {}
- name: filter_transition
  id: variable_qtgui_range
  parameters:
    label: Filter Transition Width
    min_len: '100'
    orient: Qt.Horizontal
    start: '1000'
    step: '500'
    stop: '50000'
    value: '2000'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    label: Noise Voltage
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0'
  states: {}
- name: quadrature_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: radio_audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_multiplier
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: quadrature_rate*samp_multiplier
  states: {}
- name: transmit_deviation
  id: variable_qtgui_range
  parameters:
    label: Transmission Max Deviation
    orient: Qt.Horizontal
    start: '2500'
    step: '500'
    stop: '24000'
    value: '18000'
  states: {}
- name: transmit_volume
  id: variable_qtgui_range
  parameters:
    label: Transmit Volume
    min_len: '100'
    orient: Qt.Vertical
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
    widget: slider
  states: {}
- name: transmitter_bb
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Transmitter BB Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: transmitter_if
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Transmitter IF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: transmitter_rf
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Transmitter RF gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '40'
    value: '0'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: radio_audio_rate
    fh: '-1.0'
    max_dev: transmit_deviation
    quad_rate: quadrature_rate
    tau: '75e-6'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    alias: transmit_volume
    const: transmit_volume
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/groundstation/Documents/GS-Radio/APT-Transmit/NOAA-15-20210703.wav
    repeat: 'False'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise_voltage
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: filter_cutoff
    decim: '1'
    gain: '1'
    samp_rate: quadrature_rate
    type: fir_filter_ccf
    width: filter_transition
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: transmitter_bb
    freq0: center_freq
    gain0: transmitter_rf
    if_gain0: transmitter_if
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: '0,0,3,1 '
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: radio_audio_rate
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: samp_multiplier
    taps: ''
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ch_mod
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: ch_mod
  states: {}

connections:
- [analog_nbfm_tx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [channels_channel_model_0, '0', virtual_sink_0, '0']
- [low_pass_filter_0, '0', channels_channel_model_0, '0']
- [rational_resampler_xxx_0, '0', analog_nbfm_tx_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_1, '0']

metadata:
  file_format: 1
