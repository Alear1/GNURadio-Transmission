options:
  parameters:
    author: groundstation
    generate_options: qt_gui
    id: WBFM_APT_Transmitter
    output_language: python
    title: WBFM-APT-Transmit-Jan2-2022
  states: {}

blocks:
- name: QR_multiplier
  id: variable
  parameters:
    value: '16'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '22050'
  states: {}
- name: input_selector
  id: variable_qtgui_chooser
  parameters:
    label: Input Selection
    label0: WAV File Source
    label1: Microphone Input
    label2: Mute
    num_opts: '3'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: noise_volume
  id: variable_qtgui_range
  parameters:
    label: Noise Volume
    min_len: '10'
    orient: Qt.Horizontal
    start: '0'
    step: '0.02'
    stop: '2'
    value: '0.02'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: audio_rate*QR_multiplier*10
  states: {}
- name: transmit_freq
  id: variable_qtgui_range
  parameters:
    label: Transmit Frequency
    orient: Qt.Horizontal
    start: '144500000'
    step: '10000'
    stop: '145500000'
    value: '145000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: QR_multiplier
    quad_rate: audio_rate*QR_multiplier
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: '34000'
    quad_rate: audio_rate*QR_multiplier
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '22050'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:0,0
    samp_rate: '22050'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: input_selector
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/groundstation/Documents/APT-Transmit/WBFM_Test1.wav
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/groundstation/Documents/APT-Transmit/090729 1428 noaa-18.wav
    repeat: 'True'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise_volume
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate*QR_multiplier
    type: fir_filter_ccf
    width: '40000'
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: 100e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.001'
    interp: '2'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: samp_rate / (audio_rate * QR_multiplier)
    taps: ''
    type: ccc
  states: {state: disabled}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', blocks_wavfile_sink_0, '0']
- [analog_wfm_tx_0, '0', low_pass_filter_0, '0']
- [audio_source_0, '0', blocks_selector_0, '1']
- [blocks_multiply_const_vxx_0, '0', analog_wfm_rcv_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_null_source_0, '0', blocks_selector_0, '2']
- [blocks_selector_0, '0', analog_wfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [channels_channel_model_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', channels_channel_model_0, '0']
- [rational_resampler_xxx_0, '0', blocks_selector_0, '0']
- [rational_resampler_xxx_1, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
